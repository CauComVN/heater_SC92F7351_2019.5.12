# Keil uVision project heater_2019.5.12.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7321 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: heater_2019.5.12 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source Group 1
    ./: STARTUP.A51 readme.txt
  group src
    ./src/: ADC_Init.c main.c IO_Init.c waterdetection.c leakage.c
  group include
    ./include/: Function_Init.H SC92F732X_C.H
